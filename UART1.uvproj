# Keil uVision project UART1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: UART1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SoftProject
  asm include: ..\SoftProject
  group Source Group 1
    ./: main.c UART1.c delay.c lcd.c DS18.c
