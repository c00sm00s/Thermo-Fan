# Keil uVision project Thermo-Fan.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Thermo-Fan +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SoftProject;.\USER
  asm include: ..\SoftProject
  group New Group
    ./USER/: ad0832.c delay.c dh11.c DS18.c ds1302.c lcd.c main.c PID.c UART1.c
